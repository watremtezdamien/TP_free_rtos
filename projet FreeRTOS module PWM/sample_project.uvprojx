# Keil uVision project sample_project.uvprojx, settings and files
target mcb1768 (ARM-ADS)
  device: LPC1766 NXP
  pack: Keil.LPC1700_DFP.2.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: t290nt_1768
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: CORE_M3
  c include: .\lpcopen\software\lpc_core\lpc_chip\chip_17xx_40xx;.\lpcopen\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x;.\lpcopen\software\lpc_core\lpc_chip\chip_common;.\lpcopen\software\lpc_core\lpc_board\boards_17xx\nxp_mcb_1768;.\lpcopen\software\lpc_core\lpc_board\board_common;.\lpcopen\software\freertos\freertos\Source\include;lpcopen\software\freertos\freertos\Source\portable\RVDS\ARM_CM3;..\PWM;.\FreeRTOS-Plus-Trace\Include;.\FreeRTOS-Plus-Trace\ConfigurationTemplate;.\CMSIS\CMSIS\Include
  asm define: CORE_M3
  asm misc: --cpreproc
  asm include: .\lpcopen\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x;.\lpcopen\software\lpc_core\lpc_board\boards_17xx\nxp_mcb_1768;..\FR+Trace
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup
    ./lpcopen/applications/lpc17xx_40xx/startup_code/: sysinit.c
    ./lpcopen/applications/lpc17xx_40xx/examples/freertos/startup_code/: keil_freertos_startup_lpc17xx40xx.s
  group board
    ./lpcopen/software/lpc_core/lpc_board/boards_17xx/nxp_mcb_1768/: board.c board_sysinit.c
  group chip
    ./lpcopen/software/lpc_core/lpc_chip/chip_17xx_40xx/: wwdt_17xx_40xx.c adc_17xx_40xx.c can_17xx_40xx.c chip_17xx_40xx.c clock_17xx_40xx.c cmp_17xx_40xx.c crc_17xx_40xx.c dac_17xx_40xx.c eeprom_17xx_40xx.c emc_17xx_40xx.c enet_17xx_40xx.c gpdma_17xx_40xx.c gpio_17xx_40xx.c gpioint_17xx_40xx.c i2c_17xx_40xx.c i2s_17xx_40xx.c iocon_17xx_40xx.c lcd_17xx_40xx.c pmu_17xx_40xx.c ritimer_17xx_40xx.c rtc_17xx_40xx.c sdc_17xx_40xx.c sdmmc_17xx_40xx.c spi_17xx_40xx.c ssp_17xx_40xx.c stopwatch_17xx_40xx.c sysctl_17xx_40xx.c sysinit_17xx_40xx.c timer_17xx_40xx.c uart_17xx_40xx.c
    ./lpcopen/software/lpc_core/lpc_chip/chip_common/: ring_buffer.c
    ./: pwm.c
  group FreeRTOS
    ./lpcopen/software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ./lpcopen/software/freertos/freertos/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./lpcopen/software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ./lpcopen/software/freertos/freertos/Source/portable/RVDS/ARM_CM3/: port.c
  group appli
    ../temps reel/TP_free_rtos/projet FreeRTOS module PWM/: main.c
  group FreeRTOS+Trace
    ./FreeRTOS-Plus-Trace/: trcBase.c trcHardwarePort.c trcKernel.c trcKernelPort.c trcUser.c
