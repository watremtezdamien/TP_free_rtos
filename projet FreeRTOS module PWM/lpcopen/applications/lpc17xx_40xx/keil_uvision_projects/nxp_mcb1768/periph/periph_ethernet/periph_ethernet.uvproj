# Keil uVision project periph_ethernet.uvproj, settings and files
target mcb_1768 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ethernet_iflash_nxp_lpcxpresso_1769
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core;..\..\..\..\..\..\software\CMSIS;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769
  asm define: CORE_M3
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group example
    ../../../../startup_code/: sysinit.c
    ../../../../examples/periph/periph_ethernet/: enet.c
  group chip_support_package
    ../../../../../../software/lpc_core/lpc_chip/chip_17xx_40xx/: wwdt_17xx_40xx.c adc_17xx_40xx.c can_17xx_40xx.c chip_17xx_40xx.c clock_17xx_40xx.c cmp_17xx_40xx.c crc_17xx_40xx.c dac_17xx_40xx.c eeprom_17xx_40xx.c emc_17xx_40xx.c enet_17xx_40xx.c gpdma_17xx_40xx.c gpio_17xx_40xx.c gpioint_17xx_40xx.c i2c_17xx_40xx.c i2s_17xx_40xx.c iocon_17xx_40xx.c lcd_17xx_40xx.c pmu_17xx_40xx.c ritimer_17xx_40xx.c rtc_17xx_40xx.c sdc_17xx_40xx.c sdmmc_17xx_40xx.c spi_17xx_40xx.c ssp_17xx_40xx.c stopwatch_17xx_40xx.c sysctl_17xx_40xx.c sysinit_17xx_40xx.c timer_17xx_40xx.c uart_17xx_40xx.c
    ../../../../../../software/lpc_core/lpc_chip/chip_common/: ring_buffer.c
    ../../../../../../software/lpc_core/lpc_board/board_common/: lpc_phy_dp83848.c
  group board_support_package
    ../../../../../../software/lpc_core/lpc_board/boards_17xx/nxp_mcb_1768/: board.c board_sysinit.c
  group startup
    ../../../../startup_code/: keil_startup_lpc175x_6x.s
