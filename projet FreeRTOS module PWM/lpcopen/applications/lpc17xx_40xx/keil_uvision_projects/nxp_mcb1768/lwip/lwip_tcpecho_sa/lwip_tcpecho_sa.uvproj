# Keil uVision project lwip_tcpecho_sa.uvproj, settings and files
target mcb_1768 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(100000000) ELITTLE
  output: lwip_sa_iflash_nxp_lpcxpresso_1769
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORE_M3 LWIP_DEBUG
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core;..\..\..\..\..\..\software\CMSIS;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769;..\..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\..\software\lwip\contrib\apps\tcpecho_raw;..\..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\examples\lwip\lwip_tcpecho_sa\configs
  asm define: CORE_M3
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group example
    ../../../../../../software/lwip/contrib/apps/tcpecho_raw/: echo.c
    ../../../../examples/lwip/lwip_tcpecho_sa/: lwip_tcpecho_sa.c
    ../../../../startup_code/: sysinit.c
  group LWIP
    ../../../../../../software/lwip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../../software/lwip/lwip/src/core/ipv4/: ip_frag.c ip_addr.c ip.c inet_chksum.c inet.c igmp.c icmp.c autoip.c
    ../../../../../../software/lwip/lwip/src/netif/: etharp.c
  group lpclwip
    ../../../../../../software/lwip/lpclwip/arch/: lpc_debug.c lpc17xx_40xx_systick_arch.c lpc17xx_40xx_emac.c
  group chip_support_package
    ../../../../../../software/lpc_core/lpc_chip/chip_17xx_40xx/: wwdt_17xx_40xx.c adc_17xx_40xx.c can_17xx_40xx.c chip_17xx_40xx.c clock_17xx_40xx.c cmp_17xx_40xx.c crc_17xx_40xx.c dac_17xx_40xx.c eeprom_17xx_40xx.c emc_17xx_40xx.c enet_17xx_40xx.c gpdma_17xx_40xx.c gpio_17xx_40xx.c gpioint_17xx_40xx.c i2c_17xx_40xx.c i2s_17xx_40xx.c iocon_17xx_40xx.c lcd_17xx_40xx.c pmu_17xx_40xx.c ritimer_17xx_40xx.c rtc_17xx_40xx.c sdc_17xx_40xx.c sdmmc_17xx_40xx.c spi_17xx_40xx.c ssp_17xx_40xx.c stopwatch_17xx_40xx.c sysctl_17xx_40xx.c sysinit_17xx_40xx.c timer_17xx_40xx.c uart_17xx_40xx.c
    ../../../../../../software/lpc_core/lpc_chip/chip_common/: ring_buffer.c
  group board_support_package
    ../../../../../../software/lpc_core/lpc_board/boards_17xx/nxp_mcb_1768/: board.c board_sysinit.c
    ../../../../../../software/lpc_core/lpc_board/board_common/: lpc_phy_dp83848.c
  group startup
    ../../../../examples/lwip/startup_code/: keil_startup_lpc17xx_40xx.s
