# Keil uVision project PWM.uvprojx, settings and files
target PWM (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM
  c flags: Optim=1 wLevel=2
  c include: ..\..\FreeRTOS\include;.\freertos;..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\common;.\CMSIS\CMSIS\Include;.\CMSIS\Device\ARM\ARMCM3\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group main
    ./: main.c
  group freertos
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../../FreeRTOS/portable/MemMang/: heap_1.c
  group System
    ./: startup_MPS_CM3.s
software components: CMSIS:CORE 3.40.0
